# Keil uVision project RTOS_debug.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: RTOS_debug +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: .\my_drvise;.\Debug;.\seriver;.\user
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group mydrvise
    ./my_drvise/: my_Encoder.c my_Encoder.h my_Motor.c my_Motor.h my_PID.c my_PID.h my_IMU.c my_IMU.h my_UWB.c my_UWB.h my_servo.c my_servo.h my_key.c my_key.h my_OLED.c my_OLED.h my_OLED_Font.c my_OLED_Font.h my_Buzzer.c my_Buzzer.h my_ultrasonic_ADC.c my_ultrasonic_ADC.h EEPROM.c EEPROM.h HC_04.c HC_04.h HC_04protocol.h my_LED.c my_LED.h
  group seriver
    ./seriver/: trilateration.c trilateration.h User_show.c User_show.h
  group user
    ./user/: car.c car.h
  group debug
    ./Debug/: debug.c debug.h
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c Car_Thread_entry.c new_thread0_entry.c.bak Show_Thread_entry.c LED_Thread_entry.c
software components: Flex Software:RA Configuration 1.0.0
